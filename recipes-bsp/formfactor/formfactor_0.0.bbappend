FILESEXTRAPATHS_prepend_mini2440 := "${THISDIR}/${PN}:"

PRINC = "1"
